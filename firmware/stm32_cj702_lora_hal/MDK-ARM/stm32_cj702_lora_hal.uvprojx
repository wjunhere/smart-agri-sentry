# Keil uVision project stm32_cj702_lora_hal.uvprojx, settings and files
target STM32F103RC (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: stm32_cj702_lora_hal +hex
  c flags: OneElfS=1
  c define: USE_HAL_DRIVER, STM32F103xE
  c misc: --c99
  c include: ..\Core\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xC000
  group Application/User
    ../Core/Src/: main.c gpio.c usart.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c cj702.c aggregator.c lora_frame.c lora_tx.c status_led.c app_fsm.c leaf_sensor.c soil_sensor.c system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group MDK-ARM
    ./: startup_stm32f10x_hd.s
